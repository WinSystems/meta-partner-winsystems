FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += " file://0001-Adding-DTS-support-for-itx-p-c444.patch "
