EXTRA_OEMAKE:append:imx8mq-itx-p-c444 = " \
    BL32_BASE=0x56000000 \
"
